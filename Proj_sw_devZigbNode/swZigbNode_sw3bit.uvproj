# Keil uVision project swZigbNode_sw3bit.uvproj, settings and files
target Zigb子节点设备_L7系列 (MCS-51)
  device: STC8F2K64S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x07FF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: swZigbNode_L7dev +hex
  c flags: Optimize=9
  c include: .\Usr;.\Usr_lib;.\std_Lib;.\dataTrans;.\Actuator;.\Sensor;.\hwDriver
  link misc: REMOVEUNUSED
  group 用户文件
    ./Usr/: Usr_Main.c appTimer.c dataManage.c Tips.c devlopeDebug.c
  group 数据传输
    ./dataTrans/: dataTrans.c
  group 传感器
    ./Sensor/: usrKin.c DS18B20.c
  group 执行器
    ./Actuator/: Relay.c timerAct.c touchPad.c driver_I2C_HXD019D.c
  group 外设库
    ./std_Lib/: USART.C delay.c EEPROM.c
  group 自定义方法
    ./Usr_lib/: pars_Method.c
